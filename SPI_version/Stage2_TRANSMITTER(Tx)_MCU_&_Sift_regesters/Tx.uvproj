# Keil uVision project Tx.uvproj, settings and files
target Target 1 (MCS-51)
  device: ADuC841 Analog Devices
  cpu: IRAM(0-0xFF) IROM(0-0xF7FF) XRAM (0-0x7FF) CLOCK(12000000) DPX MODAB2
  output: Tx
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: tx_ecc.c tx_ecc.h tx_encoder.c tx_encoder.h tx_header.h tx_main.c tx_main.h ECC.c common_types.h main.h peripherals.h bus_encoder.h ecc.h tx_handler.h shift_output.h Init_PESEC_Matrices.c Init_PESEC_Matrices.h
